File: Orion.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: PCB work
Other:
- removed sheet Power - Sequencing
- removed sheet Revision History
